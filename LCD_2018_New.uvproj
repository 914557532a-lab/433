# Keil uVision project LCD_2018_New.uvproj, settings and files
target LCD_2018_NEW (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: HC_K002_PTRF_G2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ConfigFile;.\CMT2300A
  link misc: REMOVEUNUSED
  group Source Group
    ./: STARTUP.A51
    ./SourceFile/: WT588Fxx.c LCD_Driver.C Flash_DATA.C DisplayProcess.C HP_03N_DRV.C KeyEventProcess.C UART_2_ISR .C Time0_Interrupt.C RTC_DRVIER_ISR.C PWM_Driver.C RF_Receiver.C Main.C
  group Drive Group
    ./CMT2300A/: CMT2300_DRV.C CMT2300_HAL.C Radio.C
